# IAR project demo-udp.ewp, settings and files
configuration LUMS_CLI_CLP (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 320
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MAC_ADDR_WORD=0x112c; NETSTK_CFG_FREQ_BAND=2; NET_USE_RPL=1; DEMO_USE_LUMS=1; DEMO_LUMS_SERVER=0; IAR_COMPILER
  ICC430.CCDiagSuppress: Pa050, Pe161
  ICC430.newCCIncludePaths: $EMB6_ROOT$\demo\lums; $EMB6_ROOT$\target; $EMB6_ROOT$\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; $EMB6_ROOT$\target\bsp\lums; $EMB6_ROOT$\target\if\cc112x; $EMB6_ROOT$\target\mcu\msp430f5438a; $EMB6_ROOT$\utils\inc; $EMB6_ROOT$\emb6; $EMB6_ROOT$\emb6\inc; $EMB6_ROOT$\emb6\inc\net; $EMB6_ROOT$\emb6\inc\net\ipv6; $EMB6_ROOT$\emb6\inc\net\ipv6\multicast; $EMB6_ROOT$\emb6\inc\net\rpl; $EMB6_ROOT$\emb6\inc\net\sicslowpan; $EMB6_ROOT$\emb6\inc\sock; $EMB6_ROOT$\emb6\inc\dll\dllsec; $EMB6_ROOT$\emb6\inc\dll\dllc; $EMB6_ROOT$\emb6\inc\dll\mac; $EMB6_ROOT$\emb6\inc\dll\framer; $EMB6_ROOT$\emb6\inc\phy
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration LUMS_SRV_CLP (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MAC_ADDR_WORD=0xcafe; NETSTK_CFG_FREQ_BAND=2; NET_USE_RPL=1; EMB6_INIT_ROOT=1; DEMO_USE_LUMS=1; DEMO_LUMS_SERVER=1; IAR_COMPILER
configuration LUMS_CLI_WOR (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MAC_ADDR_WORD=0x112c; NETSTK_CFG_FREQ_BAND=2; NETSTK_CFG_WOR_EN=1; NET_USE_RPL=1; DEMO_USE_LUMS=1; DEMO_LUMS_SERVER=0; IAR_COMPILER
configuration LUMS_SRV_WOR (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MAC_ADDR_WORD=0xcafe; NETSTK_CFG_FREQ_BAND=2; NETSTK_CFG_WOR_EN=1; NET_USE_RPL=1; DEMO_USE_LUMS=1; DEMO_LUMS_SERVER=1; IAR_COMPILER
  group demo
    ../../../../../../../../demo/: demo_main.c
  group emb6/demo/lums
    ../../../../../../../../demo/lums/: demo_lums.c lums_menu.c
  group emb6/emb6
    ../../../../../../../../emb6/: emb6.c
  group emb6/emb6/src/dll/dllc
    ../../../../../../../../emb6/src/dll/dllc/: dllc_802154.c dllc_null.c linkaddr.c
  group emb6/emb6/src/dll/dllsec
    ../../../../../../../../emb6/src/dll/dllsec/: dllsec_null.c
  group emb6/emb6/src/dll/framer
    ../../../../../../../../emb6/src/dll/framer/: framer_802154.c framer_802154_ll.c
  group emb6/emb6/src/dll/mac
    ../../../../../../../../emb6/src/dll/mac/: mac_802154.c mac_null.c
  group emb6/emb6/src/net
    ../../../../../../../../emb6/src/net/: link-stats.c net-debug.c
  group emb6/emb6/src/net/ipv6
    ../../../../../../../../emb6/src/net/ipv6/: nbr-table.c tcpip.c uip-debug.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nameserver.c uip-nd6.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip6.c uiplib.c
  group emb6/emb6/src/net/ipv6/multicast
    ../../../../../../../../emb6/src/net/ipv6/multicast/: roll-tm.c smrf.c uip-mcast6-route.c uip-mcast6-stats.c
  group emb6/emb6/src/net/rpl
    ../../../../../../../../emb6/src/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-nbr-policy.c rpl-ns.c rpl-of0.c rpl-timers.c rpl.c
  group emb6/emb6/src/net/sicslowpan
    ../../../../../../../../emb6/src/net/sicslowpan/: framer-802154.c sicslowpan.c
  group emb6/emb6/src/phy
    ../../../../../../../../emb6/src/phy/: phy_802154.c phy_framer_802154.c phy_null.c
  group emb6/emb6/src/sock
    ../../../../../../../../emb6/src/sock/: tcp-socket.c udp-socket.c
  group emb6/target/arch/msp430/msp430x5/ti/device/msp430f5xxx/src
    ../../../device/msp430f5xxx/src/: infoflash.c int.c io.c key.c lcd.c lcd_dogm128_6_alphabet.c led.c low_level_init.c mcu.c rtc.c spi.c tmr.c uart.c
  group emb6/target/bsp
    ../../../../../../../bsp/: bsp.c
  group emb6/target/bsp/lums
    ../../../../../../../bsp/lums/: board_conf.c
  group emb6/target/if/cc112x
    ../../../../../../../if/cc112x/: cc112x.c cc112x_frontend.c cc112x_spi.c
  group emb6/target/mcu/msp430f5438a
    ../../../../../../../mcu/msp430f5438a/: msp430x5xx.c
  group emb6/utils/src
    ../../../../../../../../utils/src/: clp.c crc.c ctimer.c etimer.c evproc.c list.c memb.c mmem.c packetbuf.c queuebuf.c random.c ringbuffer.c rt_tmr.c stimer.c timer.c
