# IAR project demo-udp.ewp, settings and files
configuration CC120x_SRV (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 320
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MAC_ADDR_WORD=0xcafe; LOGGER_LEVEL=3; NET_USE_RPL=1; EMB6_INIT_ROOT=1; DEMO_USE_UDP_SOCKET=1; DEMO_UDP_SOCKET_ROLE_SERVER=1; IAR_COMPILER
  ICC430.CCDiagSuppress: Pa050, Pe161
  ICC430.newCCIncludePaths: $EMB6_ROOT$\demo\udp_socket; $EMB6_ROOT$\target; $EMB6_ROOT$\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; $EMB6_ROOT$\target\bsp\ti_trxeb_cc120x; $EMB6_ROOT$\target\if\cc120x; $EMB6_ROOT$\target\mcu\msp430f5438a; $EMB6_ROOT$\utils\inc; $EMB6_ROOT$\emb6; $EMB6_ROOT$\emb6\inc; $EMB6_ROOT$\emb6\inc\net; $EMB6_ROOT$\emb6\inc\net\ipv6; $EMB6_ROOT$\emb6\inc\net\ipv6\multicast; $EMB6_ROOT$\emb6\inc\net\rpl; $EMB6_ROOT$\emb6\inc\net\sicslowpan; $EMB6_ROOT$\emb6\inc\sock; $EMB6_ROOT$\emb6\inc\dll\dllsec; $EMB6_ROOT$\emb6\inc\dll\dllc; $EMB6_ROOT$\emb6\inc\dll\mac; $EMB6_ROOT$\emb6\inc\dll\framer; $EMB6_ROOT$\emb6\inc\phy
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration CC120x_CLI (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MAC_ADDR_WORD=0x120c; LOGGER_LEVEL=1; LOGGER_DEMO_UDP_SOCKET=1; NET_USE_RPL=1; DEMO_USE_UDP_SOCKET=1; DEMO_UDP_SOCKET_ROLE_CLIENT; IAR_COMPILER
configuration CC112x_SRV (MSP430, debug)
  as the first configuration, except:
  ICC430.newCCIncludePaths: $EMB6_ROOT$\demo\udp_socket; $EMB6_ROOT$\target; $EMB6_ROOT$\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; $EMB6_ROOT$\target\bsp\ti_trxeb_cc112x; $EMB6_ROOT$\target\if\cc112x; $EMB6_ROOT$\target\mcu\msp430f5438a; $EMB6_ROOT$\utils\inc; $EMB6_ROOT$\emb6; $EMB6_ROOT$\emb6\inc; $EMB6_ROOT$\emb6\inc\net; $EMB6_ROOT$\emb6\inc\net\ipv6; $EMB6_ROOT$\emb6\inc\net\ipv6\multicast; $EMB6_ROOT$\emb6\inc\net\rpl; $EMB6_ROOT$\emb6\inc\net\sicslowpan; $EMB6_ROOT$\emb6\inc\sock; $EMB6_ROOT$\emb6\inc\dll\dllsec; $EMB6_ROOT$\emb6\inc\dll\dllc; $EMB6_ROOT$\emb6\inc\dll\mac; $EMB6_ROOT$\emb6\inc\dll\framer; $EMB6_ROOT$\emb6\inc\phy
configuration CC112x_CLI (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MAC_ADDR_WORD=0x112c; LOGGER_LEVEL=0; NET_USE_RPL=1; DEMO_USE_UDP_SOCKET=1; DEMO_UDP_SOCKET_ROLE_CLIENT; IAR_COMPILER
  ICC430.newCCIncludePaths: as above
configuration cc112x_udp_socket_client (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MAC_ADDR_WORD=0x1120; LOGGER_LEVEL=0; LOGGER_DEMO_UDP_SOCKET=0; EMB6_INIT_ROOT=0; NET_USE_RPL=1; DEMO_USE_UDP_SOCKET=1; DEMO_UDP_SOCKET_ROLE_CLIENT; IAR_COMPILER
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\; ..\..\..\..\..\..\..\..\..\emb6\demo\udp_socket; ..\..\..\..\..\..\..\..\..\emb6\target; ..\..\..\..\..\..\..\..\..\emb6\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; ..\..\..\..\..\..\..\..\..\emb6\target\bsp\ti_trxeb_cc112x_ule; ..\..\..\..\..\..\..\..\..\emb6\target\if\cc112x; ..\..\..\..\..\..\..\..\..\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\emb6\emb6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6\multicast; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\rpl; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\tport; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllsec; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\phy; ..\..\..\..\..\..\..\..\..\emb6\utils\inc
configuration LUMS_CLI (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MAC_ADDR_WORD=0x112c; NETSTK_CFG_FREQ_BAND=2; LOGGER_LEVEL=0; NET_USE_RPL=1; DEMO_USE_UDP_SOCKET=1; DEMO_UDP_SOCKET_ROLE_CLIENT; IAR_COMPILER
  ICC430.newCCIncludePaths: $EMB6_ROOT$\demo\udp_socket; $EMB6_ROOT$\target; $EMB6_ROOT$\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; $EMB6_ROOT$\target\bsp\lums; $EMB6_ROOT$\target\if\cc112x; $EMB6_ROOT$\target\mcu\msp430f5438a; $EMB6_ROOT$\utils\inc; $EMB6_ROOT$\emb6; $EMB6_ROOT$\emb6\inc; $EMB6_ROOT$\emb6\inc\net; $EMB6_ROOT$\emb6\inc\net\ipv6; $EMB6_ROOT$\emb6\inc\net\ipv6\multicast; $EMB6_ROOT$\emb6\inc\net\rpl; $EMB6_ROOT$\emb6\inc\net\sicslowpan; $EMB6_ROOT$\emb6\inc\sock; $EMB6_ROOT$\emb6\inc\dll\dllsec; $EMB6_ROOT$\emb6\inc\dll\dllc; $EMB6_ROOT$\emb6\inc\dll\mac; $EMB6_ROOT$\emb6\inc\dll\framer; $EMB6_ROOT$\emb6\inc\phy
configuration LUMS_SRV (MSP430, debug)
  as the first configuration, except:
  ICC430.newCCIncludePaths: as above
  group demo
    ../../../../../../../../demo/: demo_main.c
  group emb6/demo/udp_alive
    ../../../../../../../../demo/udp_alive/: demo_udp_alive.c demo_udp_alive.h
  group emb6/demo/udp_socket
    ../../../../../../../../demo/udp_socket/: demo_udp_socket.c
  group emb6/emb6
    ../../../../../../../../emb6/: emb6.c
  group emb6/emb6/src/dll/dllc
    ../../../../../../../../emb6/src/dll/dllc/: dllc_802154.c dllc_null.c linkaddr.c
  group emb6/emb6/src/dll/dllsec
    ../../../../../../../../emb6/src/dll/dllsec/: dllsec_null.c
  group emb6/emb6/src/dll/framer
    ../../../../../../../../emb6/src/dll/framer/: framer_802154.c framer_802154_ll.c
  group emb6/emb6/src/dll/mac
    ../../../../../../../../emb6/src/dll/mac/: mac_802154.c mac_null.c
  group emb6/emb6/src/net
    ../../../../../../../../emb6/src/net/: link-stats.c net-debug.c
  group emb6/emb6/src/net/ipv6
    ../../../../../../../../emb6/src/net/ipv6/: nbr-table.c tcpip.c uip-debug.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nameserver.c uip-nd6.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip6.c uiplib.c
  group emb6/emb6/src/net/ipv6/multicast
    ../../../../../../../../emb6/src/net/ipv6/multicast/: roll-tm.c smrf.c uip-mcast6-route.c uip-mcast6-stats.c
  group emb6/emb6/src/net/rpl
    ../../../../../../../../emb6/src/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-nbr-policy.c rpl-ns.c rpl-of0.c rpl-timers.c rpl.c
  group emb6/emb6/src/net/sicslowpan
    ../../../../../../../../emb6/src/net/sicslowpan/: framer-802154.c sicslowpan.c
  group emb6/emb6/src/phy
    ../../../../../../../../emb6/src/phy/: phy_802154.c phy_framer_802154.c phy_null.c
  group emb6/emb6/src/sock
    ../../../../../../../../emb6/src/sock/: tcp-socket.c udp-socket.c
  group emb6/target/arch/msp430/msp430x5/ti/device/msp430f5xxx/src
    ../../../device/msp430f5xxx/src/: infoflash.c int.c io.c key.c lcd.c lcd_dogm128_6_alphabet.c led.c low_level_init.c mcu.c rtc.c spi.c tmr.c uart.c
  group emb6/target/bsp
    ../../../../../../../bsp/: bsp.c
  group emb6/target/bsp/lums
    ../../../../../../../bsp/lums/: board_conf.c
  group emb6/target/bsp/ti_trxeb_cc112x
    ../../../../../../../bsp/ti_trxeb_cc112x/: board_conf.c
  group emb6/target/bsp/ti_trxeb_cc112x_ule
    ../../../../../../../bsp/ti_trxeb_cc112x_ule/: board_conf.c
  group emb6/target/bsp/ti_trxeb_cc120x
    ../../../../../../../bsp/ti_trxeb_cc120x/: board_conf.c
  group emb6/target/bsp/ti_trxeb_cc120x_ule
    ../../../../../../../bsp/ti_trxeb_cc120x_ule/: board_conf.c
  group emb6/target/bsp/ua_ti_trxeb_cc112x
    ../../../../../../../bsp/ua_ti_trxeb_cc112x/: board_conf.c
  group emb6/target/if/cc112x
    ../../../../../../../if/cc112x/: cc112x.c cc112x_frontend.c cc112x_spi.c
  group emb6/target/if/cc120x
    ../../../../../../../if/cc120x/: cc120x.c cc120x_spi.c
  group emb6/target/mcu/msp430f5438a
    ../../../../../../../mcu/msp430f5438a/: msp430x5xx.c
  group emb6/utils/src
    ../../../../../../../../utils/src/: crc.c ctimer.c etimer.c evproc.c list.c memb.c mmem.c packetbuf.c queuebuf.c random.c ringbuffer.c rt_tmr.c stimer.c timer.c
